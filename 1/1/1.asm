.include "M32DEF.INC"
.org 0
		LDI		R16,HIGH(RAMEND)
		OUT		SPH,R16
		LDI		R16,LOW(RAMEND)
		OUT		SPL,R16
		SEC
		LDI		R16,0xFF
		OUT		DDRB,R16
MY1:		LDI 	R16,0b01111111
MY2:		OUT		PORTB,R16
		ROR		R16
		CALL	DELAY
		RJMP	MY2

DELAY:	LDI 	R20,0x0F
L1:		LDI 	R21,0xFF
L2:		IN		R22,PINA
L3:		DEC		R22
		NOP
		BRNE	L3
		DEC 	R21
		BRNE 	L2
		DEC		R20
		BRNE	L1
		RET
